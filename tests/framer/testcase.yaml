## tests/framer/testcase.yaml
```yaml
tests:
  framing.parser:
    tags: framer
    platform_allow: native_sim
    integration_platforms:
      - native_sim
```
